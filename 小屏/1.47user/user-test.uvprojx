# Keil uVision project user-test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: user-test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\1.47user;.\Firmware\GD32F30x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./: main.c systick.c systick.h
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c
software components: CMSIS:CORE 5.5.0, Device:GD32F30x_StdPeripherals:RCU 2.2.0, Device:Startup 2.2.0
