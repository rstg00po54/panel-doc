# Keil uVision project TFTLCD.uvprojx, settings and files
target TFTLCD (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFT1.8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Device;..\ST-lib\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c core_cm3.h
  group Device
    ../Device/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s
  group ST-lib
    ../ST-lib/inc/: stm32f10x_rcc.h stm32f10x_gpio.h
    ../ST-lib/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group User
    ../User/: main.c gpio.c gpio.h key.c led.c
